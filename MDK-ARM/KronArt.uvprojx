# Keil uVision project KronArt.uvprojx, settings and files
target KronArt (5060020::V5.06 (build 20)::.\ARM_Compiler_5.06)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: KronArt +hex
  BeforeMake: ..\Tools\bgen.exe ..\Users\build.h
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx, HAVE_CONFIG_H, HSE_VALUE=8000000, NDEBUG, ARM_MATH_CM7
  c misc: --C99 --gnu
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;..\Users\USB\Inc;..\Users\WolfSSL\inc;..\Users\Interfaces\inc;..\Users;..\Drivers\CMSIS\RTOS\Template;..\Users\LibQRGen\inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\Users\Jansson\inc;..\Users\zlib;..\Users\libpng;..\Users\Core\inc;..\Users\libjpg;..\Users\btstack\inc;..\Users\btstack\inc\classic;..\Users\btstack\inc\ble;..\Users\btstack\platform\embedded;..\Users\btstack\chipset\cc256x;..\Drivers\BSP\STM32746G-Discovery;..\Users\eFAT\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\KronArt\KronArt.sct
  link misc: --diag_suppress=L6329
  group Interfaces
    ../Users/Interfaces/src/: if_card.c if_core.c if_ext.c if_flash.c if_net.c if_os.c if_ssl.c if_timer.c if_touch.c if_usb.c if_host.c if_boot.c if_png.c rtl8710.c if_fonts.c if_rfid.c if_pwm.c if_nfc.c if_touch_cap.c if_i2c.c if_ble.c if_gui_fmc.c if_net_gsm.c esp32.c sim8xx.c if_gps.c ssd1351.c if_sdram.c rk043fn48h.c ft5336.c if_audio.c wm8994.c if_storage.c
    ../Users/Interfaces/src/ili932x/: hz16.c ili932x.c
    ../Users/Interfaces/src/ili934x/: ili934x_fmc.c
  group GUI
    ../Users/GUI/src/: ui_alert.c ui_button.c ui_combo.c ui_core.c ui_datetime.c ui_icon.c ui_item.c ui_keyboard.c ui_label.c ui_panel.c ui_resources.c ui_scroll.c ui_setting.c ui_signal.c ui_textbox.c ui_toolbox.c ui_qrcode.c ui_gauge.c ui_image.c ui_picture.c ui_tasker.c ui_window.c ui_numbox.c ui_chart.c ui_slider.c
  group WolfSSL
    ../Users/WolfSSL/src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group WolfCrypt
    ../Users/WolfCrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c srp.c tfm.c wc_encrypt.c wc_port.c
  group Toolkit
    ../Users/Toolkit/src/: tk_core.c tk_corterra.c tk_main.c tk_resource.c tk_setting.c tk_usb.c tk_util.c tk_kernel.c tk_framework.c
  group Global Platform
    ../Users/GP/src/: gp_core.c
  group Ether
    ../Users/Ether/src/: coap.c dns.c http.c https.c raw.c owl.c ntp.c smtp.c netbios.c netbios_query.c netbios_session.c netbios_utils.c netbios_ns.c
  group Crypto
    ../Users/Crypto/src/: cr_aes.c cr_core.c cr_crc.c cr_crypt.c cr_des.c cr_mac.c cr_pandora.c cr_sha1.c cr_md5.c cr_sha256.c
  group USB
    ../Users/USB/Src/: usb_device.c usbd_conf.c usbd_custom_hid_if.c usbd_desc.c
    ../Src/: stm32f7xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
    ./: SVC_Table.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sram.c stm32f7xx_hal_rng.c stm32f7xx_hal_tim.c stm32f7xx_hal_uart.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_mmc.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group LibQRGen
    ../Users/LibQRGen/src/: bitstream.c mask.c mmask.c mqrspec.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group Jansson
    ../Users/Jansson/src/: error.c hashtable.c hashtable_seed.c load.c memory.c pack_unpack.c strbuffer.c strconv.c utf.c value.c dump.c
  group libpng
    ../Users/libpng/: png.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c pngerror.c
  group zlib
    ../Users/zlib/: adler32.c compress.c crc32.c deflate.c infback.c inffast.c inflate.c inftrees.c trees.c uncompr.c zutil.c
  group OrbWeaver
    ../Users/OrbWeaver/src/: vm_stack.c vm_runtime.c vm_alloc.c vm_framework.c va_gui.c va_comm.c va_net.c va_picc.c va_iso8583.c va_port.c va_trap_alloc.c va_trap_core.c va_ble.c
  group Core
    ../Users/Core/src/: os_core.c os_init.c os_mach_a.s os_msg.c os_debug.c
  group libjpg
    ../Users/libjpg/: cdjpeg.c jaricom.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatadst-tj.c jdatasrc.c jdatasrc-tj.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdphuff.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jidctred.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jsimd_none.c jutils.c jcomapi.c
  group Application
    ../Users/Applications/src/: power_control.c power_control_resources.c calculator.c calculator_resources.c chart_app.c chart_app_resources.c dashboard.c dashboard_resources.c spectral.c spectral_resources.c file_manager.c file_manager_resources.c vnes.c vnes_resources.c microphone.c microphone_resources.c
    ../Users/Applications/src/VNES/: core6502.cpp ppu.cpp
  group Fonts
    ../Users/Interfaces/src/fonts/: font8.c font12.c font16.c font20.c font24.c fonts29.c
  group eFAT
    ../Users/eFAT/src/: dir.c fat.c file.c ioman.c util.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
