#ifdef WIN32
//#include "stdafx.h"
#endif
#include "..\..\defs.h"
#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include "..\inc\ui_toolbox.h"
#include "..\inc\ui_resources.h"
#include "..\..\interfaces\inc\if_apis.h"

static void ui_battery_render(ui_object * obj, gui_handle_p display) {
	OS_DEBUG_ENTRY(ui_battery_render);
	uint16 x = ((ui_rect *)obj)->x;
	uint16 y = ((ui_rect *)obj)->y;
	uint16 w = ((ui_rect *)obj)->w;
	uint16 h = ((ui_rect *)obj)->h;
	uint16 yy, xx, hh, ww;
	uint32 fcolor;
	if(obj->state & UI_STATE_INIT) {
		//fill background first
		//display->fill_area(display, ((ui_object *)obj)->backcolor, display->set_area(display, x, y, w, h));
		display->set_area(display, x, y, w, h);
		xx = x + 1;
		yy = y + 6;
		hh = 12;
		ww = 4;
		if(((ui_progress *)obj)->percent > 0) fcolor = ((ui_object *)obj)->forecolor;
		else fcolor = UI_COLOR_BLACK;
		display->fill_area(display, fcolor, display->set_area(display, xx+1, yy+1, ww-2, hh-2));
		display->draw_rectangle(display, xx, yy, ww, hh, UI_COLOR_WHITE, 1);
		xx = x + 7;
		yy = y + 6;
		hh = 12;
		ww = 4;
		if(((ui_progress *)obj)->percent > 20) fcolor = ((ui_object *)obj)->forecolor;
		else fcolor = UI_COLOR_BLACK;
		display->fill_area(display, fcolor, display->set_area(display, xx+1, yy+1, ww-2, hh-2));
		display->draw_rectangle(display, xx, yy, ww, hh, UI_COLOR_WHITE, 1);
		xx = x + 13;
		yy = y + 6;
		hh = 12;
		ww = 4;
		if(((ui_progress *)obj)->percent > 40) fcolor = ((ui_object *)obj)->forecolor;
		else fcolor = UI_COLOR_BLACK;
		display->fill_area(display, fcolor, display->set_area(display, xx+1, yy+1, ww-2, hh-2));
		display->draw_rectangle(display, xx, yy, ww, hh, UI_COLOR_WHITE, 1);
		xx = x + 19;
		yy = y + 6;
		hh = 12;
		ww = 4;
		if(((ui_progress *)obj)->percent > 80) fcolor = ((ui_object *)obj)->forecolor;
		else fcolor = UI_COLOR_BLACK;
		display->fill_area(display, fcolor, display->set_area(display, xx+1, yy+1, ww-2, hh-2));
		display->draw_rectangle(display, xx, yy, ww, hh, UI_COLOR_WHITE, 1);
	}
	OS_DEBUG_EXIT();
}

static void ui_progress_render(ui_object * obj, gui_handle_p display) {
	OS_DEBUG_ENTRY(ui_progress_render);
	uint16 x = ((ui_rect *)obj)->x;
	uint16 y = ((ui_rect *)obj)->y;
	uint16 w = ((ui_rect *)obj)->w;
	uint16 h = ((ui_rect *)obj)->h;
	uint16 yy, xx, hh, ww;
	uint32 fcolor;
	if(obj->state & UI_STATE_INIT) {
		//fill background first
		//display->fill_area(display, ((ui_object *)obj)->backcolor, );
		display->set_area(display, x, y, w, h);
		xx = x + 1;
		yy = y + 6;
		hh = 12;
		ww = 4;
		if(((ui_progress *)obj)->percent > 0) fcolor = ((ui_object *)obj)->forecolor;
		else fcolor = UI_COLOR_BLACK;
		display->fill_area(display, fcolor, display->set_area(display, xx+1, yy+1, ww-2, hh-2));
		display->draw_rectangle(display, xx, yy, ww, hh, UI_COLOR_WHITE, 1);
		xx = x + 7;
		yy = y + 6;
		hh = 12;
		ww = 4;
		if(((ui_progress *)obj)->percent > 20) fcolor = ((ui_object *)obj)->forecolor;
		else fcolor = UI_COLOR_BLACK;
		display->fill_area(display, fcolor, display->set_area(display, xx+1, yy+1, ww-2, hh-2));
		display->draw_rectangle(display, xx, yy, ww, hh, UI_COLOR_WHITE, 1);
		xx = x + 13;
		yy = y + 6;
		hh = 12;
		ww = 4;
		if(((ui_progress *)obj)->percent > 40) fcolor = ((ui_object *)obj)->forecolor;
		else fcolor = UI_COLOR_BLACK;
		display->fill_area(display, fcolor, display->set_area(display, xx+1, yy+1, ww-2, hh-2));
		display->draw_rectangle(display, xx, yy, ww, hh, UI_COLOR_WHITE, 1);
		xx = x + 19;
		yy = y + 6;
		hh = 12;
		ww = 4;
		if(((ui_progress *)obj)->percent > 80) fcolor = ((ui_object *)obj)->forecolor;
		else fcolor = UI_COLOR_BLACK;
		display->fill_area(display, fcolor, display->set_area(display, xx+1, yy+1, ww-2, hh-2));
		display->draw_rectangle(display, xx, yy, ww, hh, UI_COLOR_WHITE, 1);
	}
	OS_DEBUG_EXIT();
}

void ui_icon_draw_marker(ui_object * obj, gui_handle_p display) {
	uint16 x = ((ui_rect *)obj)->x;
	uint16 y = ((ui_rect *)obj)->y;
	uint16 w = ((ui_rect *)obj)->w;
	uint16 h = ((ui_rect *)obj)->h;
	uint32 fcolor = UI_COLOR_BLUE;
	if(((ui_icon_tool *)obj)->show_marker) {
		fcolor = UI_COLOR_BLUE;
	} else {
		fcolor = obj->backcolor;
	}
	if(display->orientation & 0x01) {
		display->fill_area(display, fcolor, display->set_area(display, x, y, w, 2));
		//borders
		display->fill_area(display, UI_COLOR_RGB(49,51,59), display->set_area(display, x, y, 1, h));
		display->fill_area(display, UI_COLOR_RGB(79,81,89), display->set_area(display, (x + w) - 1, y, 1, h));
	} else {
		display->fill_area(display, fcolor, display->set_area(display, (x + w) - 2, y, 2, h));
		//borders
		display->fill_area(display, UI_COLOR_RGB(49,51,59), display->set_area(display, x, y, w, 1));
		display->fill_area(display, UI_COLOR_RGB(79,81,89), display->set_area(display, x, (y + h) - 1, w, 1));
	}
}

static void ui_icon_tool_render(ui_object * obj, gui_handle_p display) {
	uint16 nc, wtxt, xx, yy;
	uint8 ww, hh, num_pal;
	uint8 i, j, c;
	//uint32 palletes[8];
	uint16 offset;
	uint32 color;
	uint8 index;
	//ui_object frame;
	uint16 x = ((ui_rect *)obj)->x;
	uint16 y = ((ui_rect *)obj)->y;
	uint16 w = ((ui_rect *)obj)->w;
	uint16 h = ((ui_rect *)obj)->h;
	uint8 font_size = UI_FONT_DEFAULT;
	uint8 font_width = UI_FONT_DEFAULT_WIDTH;
	ui_icon_bitmap * objmp = &((ui_icon_tool *)obj)->bitmap[((ui_toggle *)obj)->state & 0x01];
	if(((ui_rect *)obj)->h <= 40) {
		font_size = UI_FONT_SMALL;
		font_width = UI_FONT_SMALL_WIDTH;
	}
	if(obj->state != 0) {
		ui_tab_render(obj, display);
		display->set_area(display, x, y, w, h);
		if(objmp != NULL) {
			ui_image_render(display, (ui_rect *)obj, objmp->bitmap, objmp->bmpsize, UI_IMAGE_ALIGN_TOP | UI_IMAGE_ALIGN_CENTER);
			if(((ui_rect *)obj)->h <= 40) goto exit_icon_tool_render;
		}
		//display->print_string(display, UI_FONT_DEFAULT, x + xx, (y + h) - UI_FONT_DEFAULT, ((ui_object *)obj)->text, ((ui_object *)obj)->forecolor);
		//if(((ui_rect *)obj)->h <= 40 && objmp != NULL) {
			//don't print text
		//} else {
		nc = strlen((const char *)((ui_text *)obj)->text);
		wtxt = nc * font_width;
		xx = ((w - wtxt) >> 1);		//x = width - text_width / 2;
		display->set_area(display, x, y, w, h);
		display->print_string(display, font_size, x + xx, (y + h) - (font_size + 1), (uint8 *)((ui_text *)obj)->text, UI_COLOR_WHITE);
		//}
		//display->fill_area(display, UI_COLOR_RGB(79,81,89), display->set_area(display, x, y + h-2, w, 1));
		//display->fill_area(display, UI_COLOR_RGB(60,62,70), display->set_area(display, x, y + h-1, w, 1));
	} 
	exit_icon_tool_render:
	ui_icon_draw_marker(obj, display);
}

void ui_launcher_draw_marker(ui_object * obj, gui_handle_p display) {
	uint16 x = ((ui_rect *)obj)->x;
	uint16 y = ((ui_rect *)obj)->y;
	uint16 w = ((ui_rect *)obj)->w;
	uint16 h = ((ui_rect *)obj)->h;
	uint32 fcolor = UI_COLOR_BLUE;
	if(((ui_icon_tool *)obj)->show_marker) {
		fcolor = UI_COLOR_LIME;
	} else {
		fcolor = obj->backcolor;
	}
	if(display->orientation & 0x01) {
		display->fill_area(display, fcolor, display->set_area(display, x + w - 4, y + 2, 4, 4));
		//borders
		//display->fill_area(display, UI_COLOR_RGB(49,51,59), display->set_area(display, x, y, 1, h));
		//display->fill_area(display, UI_COLOR_RGB(79,81,89), display->set_area(display, (x + w) - 1, y, 1, h));
	} else {
		display->fill_area(display, fcolor, display->set_area(display, x + w - 4, y + 2, 4, 4));
		//borders
		//display->fill_area(display, UI_COLOR_RGB(49,51,59), display->set_area(display, x, y, w, 1));
		//display->fill_area(display, UI_COLOR_RGB(79,81,89), display->set_area(display, x, (y + h) - 1, w, 1));
	}
}

static void ui_launcher_render(ui_object * obj, gui_handle_p display) {
	uint16 nc, wtxt, xx, yy;
	uint8 ww, hh, num_pal;
	uint8 i, j, c;
	//uint32 palletes[8];
	uint16 offset;
	uint32 color;
	uint8 index;
	//ui_object frame;
	uint16 x = ((ui_rect *)obj)->x;
	uint16 y = ((ui_rect *)obj)->y;
	uint16 w = ((ui_rect *)obj)->w;
	uint16 h = ((ui_rect *)obj)->h;
	uint8 font_size = UI_FONT_SMALL;
	uint8 font_width = UI_FONT_SMALL_WIDTH;
	ui_icon_bitmap * objmp = &((ui_icon_tool *)obj)->bitmap[((ui_toggle *)obj)->state & 0x01];
	if(((ui_rect *)obj)->h <= 40) {
		font_size = UI_FONT_SMALL;
		font_width = UI_FONT_SMALL_WIDTH;
	}
	if(obj->state != 0) {
		//ui_tab_render(obj, display);
		display->set_area(display, x, y, w, h);
		if(objmp != NULL) {
			ui_image_render(display, (ui_rect *)obj, objmp->bitmap, objmp->bmpsize, UI_IMAGE_ALIGN_TOP | UI_IMAGE_ALIGN_CENTER);
			if(((ui_rect *)obj)->h <= 40) goto exit_icon_tool_render;
		}
		//display->print_string(display, UI_FONT_DEFAULT, x + xx, (y + h) - UI_FONT_DEFAULT, ((ui_object *)obj)->text, ((ui_object *)obj)->forecolor);
		//if(((ui_rect *)obj)->h <= 40 && objmp != NULL) {
			//don't print text
		//} else {
		nc = strlen((const char *)((ui_text *)obj)->text);
		wtxt = nc * font_width;
		xx = ((w - wtxt) >> 1);		//x = width - text_width / 2;
		display->set_area(display, x, y, w, h);
		display->print_string(display, font_size, x + xx, (y + h) - font_size, (uint8 *)((ui_text *)obj)->text, UI_COLOR_WHITE);
		//}
		//display->fill_area(display, UI_COLOR_RGB(79,81,89), display->set_area(display, x, y + h-2, w, 1));
		//display->fill_area(display, UI_COLOR_RGB(60,62,70), display->set_area(display, x, y + h-1, w, 1));
	} 
	exit_icon_tool_render:
	ui_launcher_draw_marker(obj, display);
}

void ui_progress_click(ui_object * obj, void * params) {
	
}

ui_object * ui_battery_create(uint8 * name, uint8 percent) {
	ui_progress * obj = (ui_progress *)ui_create_object(sizeof(ui_progress), UI_TYPE_GRIDITEM | UI_ALIGN_GRID) ;
	obj->percent = percent;
	((ui_object *)obj)->rect.w = 24;
	((ui_object *)obj)->rect.h = 24;
	strcpy((char *)((ui_object *)obj)->name, (const char *)name);
	((ui_object *)obj)->render = ui_progress_render;
	((ui_object *)obj)->forecolor = UI_COLOR_LIME;
	((ui_object *)obj)->backcolor = UI_COLOR_QUEEN_BLUE;
	//((ui_object *)obj)->handler = ui_battery_render;
	return (ui_object *)obj;
}

ui_object * ui_progress_create(uint8 * name, uint8 percent) {
	ui_progress * obj = (ui_progress *)ui_create_object(sizeof(ui_progress), UI_TYPE_GRIDITEM | UI_ALIGN_GRID) ;
	obj->percent = percent;
	((ui_object *)obj)->rect.w = 24;
	((ui_object *)obj)->rect.h = 24;
	strcpy((char *)((ui_object *)obj)->name, (const char *)name);
	((ui_object *)obj)->render = ui_progress_render;
	((ui_object *)obj)->forecolor = UI_COLOR_LIME;
	((ui_object *)obj)->backcolor = UI_COLOR_QUEEN_BLUE;
	((ui_object *)obj)->handler = ui_progress_click;
	return (ui_object *)obj;
}

ui_object * ui_card_create(uint8 *name, uint8 * text, uint16 width, uint16 height, void (* click)(ui_object *, void *)) {
	ui_icon_tool * obj = (ui_icon_tool *)ui_create_text(sizeof(ui_icon_tool), UI_TYPE_GRIDITEM | UI_ALIGN_GRID, (char *)text) ;
	((ui_object *)obj)->rect.w = width;
	((ui_object *)obj)->rect.h = height;
	strcpy((char *)((ui_object *)obj)->name, (const char *)name);
	((ui_object *)obj)->render = ui_icon_tool_render;
	((ui_object *)obj)->forecolor = UI_COLOR_LIME;
	((ui_object *)obj)->backcolor = UI_COLOR_QUEEN_BLUE;
	//((ui_object *)obj)->target = target;
	((ui_object *)obj)->handler = click;
	((ui_toggle *)obj)->state = 0;		//toggle off, enabled
	//strcpy((char *)obj->text, (const char *)text);
	if(width <= 40 || height <= 40) {
		obj->bitmap[0].bitmap = (uint8 *)image_png_home24;
		obj->bitmap[0].bmpsize = sizeof(image_png_home24);
		obj->bitmap[1].bitmap = (uint8 *)image_png_home24;
		obj->bitmap[1].bmpsize = sizeof(image_png_home24);
	} else {
		obj->bitmap[0].bitmap = (uint8 *)image_png_owvr_off;
		obj->bitmap[0].bmpsize = sizeof(image_png_owvr_off);
		obj->bitmap[1].bitmap = (uint8 *)image_png_owvr_on;
		obj->bitmap[1].bmpsize = sizeof(image_png_owvr_on);
	}
	return (ui_object *)obj;
}

ui_object * ui_action_create(uint8 *name, uint16 w, uint16 h) {
	ui_icon_tool * obj = (ui_icon_tool *)ui_create_text(sizeof(ui_icon_tool), UI_TYPE_GRIDITEM | UI_ALIGN_GRID, "") ;
	((ui_object *)obj)->rect.w = w;
	((ui_object *)obj)->rect.h = h;
	strcpy((char *)((ui_object *)obj)->name, (const char *)name);
	((ui_object *)obj)->render = ui_icon_tool_render;
	((ui_object *)obj)->forecolor = UI_COLOR_LIME;
	((ui_object *)obj)->backcolor = UI_COLOR_QUEEN_BLUE;
	((ui_object *)obj)->target = NULL;
	((ui_object *)obj)->handler = NULL;
	((ui_toggle *)obj)->state = 0;		//toggle off, enabled
	obj->bitmap[0].bitmap = (uint8 *)NULL;
	obj->bitmap[0].bmpsize = 0;
	obj->bitmap[1].bitmap = (uint8 *)NULL;
	obj->bitmap[1].bmpsize = 0;
	return (ui_object *)obj;
}

ui_object * ui_header_create(uint8 *name, uint8* text, uint16 w, uint16 h, uint16 bmpsize, uint8 * bitmap, void (* click)(ui_object *, void *)) {
	ui_icon_tool * obj = (ui_icon_tool *)ui_create_text(sizeof(ui_icon_tool), UI_TYPE_GRIDITEM | UI_ALIGN_GRID, "") ;
	((ui_object *)obj)->rect.w = w;
	((ui_object *)obj)->rect.h = h;
	strcpy((char *)((ui_object *)obj)->name, (const char *)name);
	((ui_object *)obj)->render = ui_icon_tool_render;
	((ui_object *)obj)->forecolor = UI_COLOR_LIME;
	((ui_object *)obj)->backcolor = UI_COLOR_QUEEN_BLUE;
	((ui_object *)obj)->target = NULL;
	((ui_object *)obj)->handler = click;
	((ui_toggle *)obj)->state = 0;		//toggle off, enabled
	obj->bitmap[0].bitmap = (uint8 *)bitmap;
	obj->bitmap[0].bmpsize = bmpsize;
	obj->bitmap[1].bitmap = (uint8 *)NULL;
	obj->bitmap[1].bmpsize = 0;
	return (ui_object *)obj;
}

ui_object * ui_launcher_create(uint8 *name, uint8* text, uint16 w, uint16 h, uint16 bmpsize, uint8 * bitmap, void (* click)(ui_object *, void *)) {
	ui_icon_tool * obj = (ui_icon_tool *)ui_create_text(sizeof(ui_icon_tool), UI_TYPE_GRIDITEM | UI_ALIGN_GRID, text) ;
	((ui_object *)obj)->rect.w = w;
	((ui_object *)obj)->rect.h = h;
	strcpy((char *)((ui_object *)obj)->name, (const char *)name);
	((ui_object *)obj)->render = ui_launcher_render;
	((ui_object *)obj)->forecolor = UI_COLOR_LIME;
	((ui_object *)obj)->backcolor = UI_COLOR_BLACK;
	((ui_object *)obj)->target = NULL;
	((ui_object *)obj)->handler = click;
	((ui_toggle *)obj)->state = 0;		//toggle off, enabled
	obj->bitmap[0].bitmap = (uint8 *)bitmap;
	obj->bitmap[0].bmpsize = bmpsize;
	obj->bitmap[1].bitmap = (uint8 *)NULL;
	obj->bitmap[1].bmpsize = 0;
	return (ui_object *)obj;
}


//------------------------------------------------------------
//-----------       Created with 010 Editor        -----------
//------         www.sweetscape.com/010editor/          ------
//
// File    : C:\Users\Agus\Desktop\jongun1.jpg
// Address : 0 (0x0)
// Size    : 1561 (0x619)
//------------------------------------------------------------
uint8_c image_jpg_config[1561] = {
    0xFF, 0xD8, 0xFF, 0xE0, 0x00, 0x10, 0x4A, 0x46, 0x49, 0x46, 0x00, 0x01, 0x01, 0x01, 0x00, 0x48,
    0x00, 0x48, 0x00, 0x00, 0xFF, 0xDB, 0x00, 0x43, 0x00, 0x05, 0x03, 0x04, 0x04, 0x04, 0x03, 0x05,
    0x04, 0x04, 0x04, 0x05, 0x05, 0x05, 0x06, 0x07, 0x0C, 0x08, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0B,
    0x0B, 0x09, 0x0C, 0x11, 0x0F, 0x12, 0x12, 0x11, 0x0F, 0x11, 0x11, 0x13, 0x16, 0x1C, 0x17, 0x13,
    0x14, 0x1A, 0x15, 0x11, 0x11, 0x18, 0x21, 0x18, 0x1A, 0x1D, 0x1D, 0x1F, 0x1F, 0x1F, 0x13, 0x17,
    0x22, 0x24, 0x22, 0x1E, 0x24, 0x1C, 0x1E, 0x1F, 0x1E, 0xFF, 0xDB, 0x00, 0x43, 0x01, 0x05, 0x05,
    0x05, 0x07, 0x06, 0x07, 0x0E, 0x08, 0x08, 0x0E, 0x1E, 0x14, 0x11, 0x14, 0x1E, 0x1E, 0x1E, 0x1E,
    0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
    0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
    0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0xFF, 0xC0,
    0x00, 0x11, 0x08, 0x00, 0x30, 0x00, 0x30, 0x03, 0x01, 0x22, 0x00, 0x02, 0x11, 0x01, 0x03, 0x11,
    0x01, 0xFF, 0xC4, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x05, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09,
    0x0A, 0x0B, 0xFF, 0xC4, 0x00, 0xB5, 0x10, 0x00, 0x02, 0x01, 0x03, 0x03, 0x02, 0x04, 0x03, 0x05,
    0x05, 0x04, 0x04, 0x00, 0x00, 0x01, 0x7D, 0x01, 0x02, 0x03, 0x00, 0x04, 0x11, 0x05, 0x12, 0x21,
    0x31, 0x41, 0x06, 0x13, 0x51, 0x61, 0x07, 0x22, 0x71, 0x14, 0x32, 0x81, 0x91, 0xA1, 0x08, 0x23,
    0x42, 0xB1, 0xC1, 0x15, 0x52, 0xD1, 0xF0, 0x24, 0x33, 0x62, 0x72, 0x82, 0x09, 0x0A, 0x16, 0x17,
    0x18, 0x19, 0x1A, 0x25, 0x26, 0x27, 0x28, 0x29, 0x2A, 0x34, 0x35, 0x36, 0x37, 0x38, 0x39, 0x3A,
    0x43, 0x44, 0x45, 0x46, 0x47, 0x48, 0x49, 0x4A, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58, 0x59, 0x5A,
    0x63, 0x64, 0x65, 0x66, 0x67, 0x68, 0x69, 0x6A, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79, 0x7A,
    0x83, 0x84, 0x85, 0x86, 0x87, 0x88, 0x89, 0x8A, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97, 0x98, 0x99,
    0x9A, 0xA2, 0xA3, 0xA4, 0xA5, 0xA6, 0xA7, 0xA8, 0xA9, 0xAA, 0xB2, 0xB3, 0xB4, 0xB5, 0xB6, 0xB7,
    0xB8, 0xB9, 0xBA, 0xC2, 0xC3, 0xC4, 0xC5, 0xC6, 0xC7, 0xC8, 0xC9, 0xCA, 0xD2, 0xD3, 0xD4, 0xD5,
    0xD6, 0xD7, 0xD8, 0xD9, 0xDA, 0xE1, 0xE2, 0xE3, 0xE4, 0xE5, 0xE6, 0xE7, 0xE8, 0xE9, 0xEA, 0xF1,
    0xF2, 0xF3, 0xF4, 0xF5, 0xF6, 0xF7, 0xF8, 0xF9, 0xFA, 0xFF, 0xC4, 0x00, 0x1F, 0x01, 0x00, 0x03,
    0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
    0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B, 0xFF, 0xC4, 0x00, 0xB5, 0x11, 0x00,
    0x02, 0x01, 0x02, 0x04, 0x04, 0x03, 0x04, 0x07, 0x05, 0x04, 0x04, 0x00, 0x01, 0x02, 0x77, 0x00,
    0x01, 0x02, 0x03, 0x11, 0x04, 0x05, 0x21, 0x31, 0x06, 0x12, 0x41, 0x51, 0x07, 0x61, 0x71, 0x13,
    0x22, 0x32, 0x81, 0x08, 0x14, 0x42, 0x91, 0xA1, 0xB1, 0xC1, 0x09, 0x23, 0x33, 0x52, 0xF0, 0x15,
    0x62, 0x72, 0xD1, 0x0A, 0x16, 0x24, 0x34, 0xE1, 0x25, 0xF1, 0x17, 0x18, 0x19, 0x1A, 0x26, 0x27,
    0x28, 0x29, 0x2A, 0x35, 0x36, 0x37, 0x38, 0x39, 0x3A, 0x43, 0x44, 0x45, 0x46, 0x47, 0x48, 0x49,
    0x4A, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58, 0x59, 0x5A, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68, 0x69,
    0x6A, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79, 0x7A, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88,
    0x89, 0x8A, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97, 0x98, 0x99, 0x9A, 0xA2, 0xA3, 0xA4, 0xA5, 0xA6,
    0xA7, 0xA8, 0xA9, 0xAA, 0xB2, 0xB3, 0xB4, 0xB5, 0xB6, 0xB7, 0xB8, 0xB9, 0xBA, 0xC2, 0xC3, 0xC4,
    0xC5, 0xC6, 0xC7, 0xC8, 0xC9, 0xCA, 0xD2, 0xD3, 0xD4, 0xD5, 0xD6, 0xD7, 0xD8, 0xD9, 0xDA, 0xE2,
    0xE3, 0xE4, 0xE5, 0xE6, 0xE7, 0xE8, 0xE9, 0xEA, 0xF2, 0xF3, 0xF4, 0xF5, 0xF6, 0xF7, 0xF8, 0xF9,
    0xFA, 0xFF, 0xDA, 0x00, 0x0C, 0x03, 0x01, 0x00, 0x02, 0x11, 0x03, 0x11, 0x00, 0x3F, 0x00, 0xF0,
    0x29, 0x2D, 0x65, 0xD3, 0xEE, 0x75, 0x18, 0x30, 0xF1, 0xCD, 0x0C, 0xF2, 0x40, 0x78, 0x39, 0x27,
    0x77, 0x5F, 0xCB, 0x07, 0xF1, 0x15, 0xF5, 0x3F, 0xEC, 0xCB, 0xE1, 0x0D, 0x22, 0x0F, 0x05, 0xC3,
    0xAB, 0x5D, 0x58, 0xC1, 0x2E, 0xA5, 0x72, 0xE5, 0x9E, 0x79, 0x63, 0x05, 0x80, 0xED, 0x8C, 0xF4,
    0xAF, 0x29, 0xF1, 0x7F, 0x85, 0x75, 0x4B, 0xEF, 0x1A, 0x5A, 0x7F, 0x64, 0xD8, 0x45, 0x3C, 0x5A,
    0xAC, 0x91, 0xA4, 0xE5, 0xB8, 0x09, 0x22, 0xF0, 0x49, 0xF6, 0x2A, 0x07, 0xFD, 0xF2, 0x6B, 0xEA,
    0x1F, 0x0A, 0xE8, 0x8D, 0xA0, 0x78, 0x72, 0x0D, 0x3E, 0xC3, 0xCB, 0x91, 0xE0, 0x8C, 0x67, 0x77,
    0xCA, 0x09, 0xEF, 0xD8, 0xD6, 0x35, 0x53, 0xD9, 0x1E, 0x96, 0x02, 0x1B, 0xCD, 0x97, 0xB5, 0x0B,
    0x28, 0x82, 0x1D, 0xAC, 0xAC, 0x6B, 0x8A, 0xD7, 0xE3, 0xB9, 0x4B, 0x59, 0xE2, 0x86, 0x10, 0xE8,
    0xC0, 0xEE, 0x05, 0x72, 0x2B, 0x7A, 0xD3, 0x5C, 0x6B, 0xFB, 0xF9, 0x2C, 0x2E, 0x20, 0x86, 0x2B,
    0x94, 0xCE, 0x16, 0x29, 0x4B, 0x67, 0xDF, 0x90, 0x2B, 0x1F, 0x5C, 0xBC, 0xBA, 0xBA, 0x89, 0xE2,
    0xD2, 0x45, 0xB1, 0x74, 0xCA, 0xCC, 0xF3, 0xB9, 0x54, 0x41, 0xEF, 0x8E, 0xA7, 0xDA, 0xB8, 0xAA,
    0x52, 0x52, 0xD5, 0x33, 0xD8, 0x5C, 0xD6, 0xD5, 0x1F, 0x3D, 0x7C, 0x54, 0xF0, 0x6E, 0x97, 0x77,
    0xA6, 0x49, 0x7A, 0x96, 0xF1, 0xC1, 0x73, 0x13, 0x06, 0x2C, 0x8B, 0x8D, 0xC3, 0xB8, 0xAF, 0x22,
    0xF0, 0xE6, 0x9D, 0x21, 0xF1, 0xBD, 0x85, 0xA6, 0x9F, 0xBC, 0xBF, 0xDA, 0x53, 0x69, 0x42, 0x72,
    0xB8, 0x3C, 0x9C, 0xFA, 0x01, 0x9A, 0xFA, 0x57, 0xC5, 0x56, 0x70, 0x6A, 0xF0, 0xDC, 0xD8, 0x09,
    0xAD, 0x5E, 0x65, 0x5C, 0x38, 0xB6, 0x63, 0xC1, 0xFA, 0x12, 0x4D, 0x71, 0x5F, 0x0F, 0x7E, 0x1F,
    0x5C, 0x78, 0x6B, 0x5A, 0x9F, 0x54, 0xBD, 0x94, 0x4A, 0x1E, 0x32, 0x2D, 0xF8, 0xE9, 0x93, 0xF3,
    0x13, 0xF9, 0x01, 0xF8, 0xD5, 0x61, 0x26, 0xD4, 0x5C, 0x5B, 0xD8, 0xF2, 0x73, 0x0A, 0x5E, 0xF2,
    0x92, 0x47, 0xB8, 0x78, 0x3E, 0xD8, 0xB6, 0xA0, 0x8E, 0x56, 0x37, 0x45, 0x0C, 0xEC, 0xC5, 0x79,
    0x52, 0x0A, 0x01, 0x8F, 0x4C, 0xEE, 0x3F, 0x95, 0x7A, 0x06, 0xB9, 0xA6, 0x0B, 0x8D, 0x2F, 0x21,
    0xA4, 0x7F, 0xEF, 0x46, 0x25, 0x74, 0x07, 0xFE, 0xF9, 0x20, 0x9A, 0xF3, 0x8F, 0x00, 0xEB, 0x1A,
    0x75, 0xCB, 0xC4, 0x16, 0xE6, 0x28, 0x9E, 0xE6, 0x21, 0xB6, 0x36, 0x6C, 0x33, 0x3E, 0x41, 0xC0,
    0xFC, 0x32, 0x7F, 0x0A, 0xF4, 0x8F, 0x13, 0x6A, 0xED, 0xA4, 0x78, 0x4E, 0xF6, 0xE8, 0xAE, 0xE1,
    0x1C, 0x0C, 0xFC, 0x7B, 0x0C, 0xD7, 0x7D, 0x58, 0xC5, 0x54, 0x77, 0xEC, 0x74, 0x60, 0xA5, 0xCD,
    0x42, 0x1C, 0xAB, 0xD7, 0xEF, 0x38, 0xEF, 0x03, 0x78, 0x3E, 0xC2, 0xC3, 0xC5, 0x97, 0x7A, 0xD5,
    0xB4, 0xC7, 0x7A, 0xE7, 0x31, 0x2B, 0xB1, 0x55, 0x66, 0xCF, 0x62, 0xC7, 0xFA, 0x56, 0x01, 0x96,
    0xC5, 0x3C, 0x69, 0xA8, 0xF8, 0x7A, 0xFC, 0x43, 0x22, 0xDE, 0x4D, 0xE7, 0x5A, 0xAC, 0x84, 0xED,
    0xF3, 0x30, 0x32, 0x31, 0xD1, 0xBA, 0x71, 0x9F, 0x4A, 0xE8, 0x3E, 0x13, 0x3B, 0xD9, 0xFC, 0x3C,
    0x87, 0x5C, 0xBD, 0xD5, 0xED, 0x63, 0xD4, 0x35, 0x59, 0x5A, 0xF9, 0xE3, 0x9F, 0x69, 0xF9, 0x5B,
    0x1B, 0x50, 0x02, 0x73, 0xF7, 0x02, 0xFD, 0x09, 0x35, 0xE2, 0x3F, 0x14, 0xEE, 0x75, 0x07, 0xF1,
    0x4D, 0xCC, 0xA7, 0xC4, 0x7A, 0x74, 0x91, 0x49, 0x2A, 0xCA, 0xB1, 0x46, 0x76, 0xC8, 0x8C, 0x0E,
    0x46, 0x3D, 0xFE, 0x95, 0xC5, 0x52, 0x3C, 0x91, 0x8C, 0x8F, 0x45, 0x34, 0xF9, 0xAD, 0xB2, 0x3B,
    0xCD, 0x6B, 0xC2, 0x3A, 0x17, 0x87, 0x93, 0xED, 0xB1, 0xD8, 0xC0, 0xB7, 0x8E, 0xE0, 0x7C, 0x91,
    0xAC, 0x41, 0x17, 0xD1, 0x42, 0x81, 0x5C, 0xFF, 0x00, 0x8E, 0x6E, 0x2E, 0xFF, 0x00, 0xB4, 0xFC,
    0x2A, 0xB6, 0x8D, 0x2A, 0x42, 0xF2, 0x4A, 0x64, 0x55, 0x63, 0xB5, 0x97, 0x00, 0x10, 0x7D, 0x71,
    0x9E, 0x2A, 0x7F, 0x88, 0x9A, 0xAE, 0xA5, 0x7D, 0xE0, 0x3D, 0x0F, 0x57, 0xB9, 0xC8, 0x96, 0xEA,
    0x15, 0xF3, 0x5D, 0x4F, 0x0E, 0xC3, 0x82, 0xDF, 0x8E, 0x33, 0xED, 0x9A, 0x7E, 0x9F, 0x7B, 0x1D,
    0xD7, 0x85, 0xEC, 0x9A, 0x68, 0x95, 0xE4, 0x04, 0xF9, 0x6C, 0x7A, 0xA7, 0x6C, 0x8F, 0xA8, 0xCD,
    0x28, 0x41, 0x39, 0x3B, 0x79, 0x1C, 0x78, 0xB9, 0xC6, 0x36, 0x7E, 0xBF, 0x91, 0x87, 0x75, 0xE2,
    0x7B, 0x7D, 0x04, 0x47, 0x7E, 0x19, 0x58, 0xDB, 0x48, 0x92, 0x24, 0x2A, 0x79, 0x6C, 0x11, 0xC7,
    0xE2, 0x2B, 0xE8, 0x3B, 0x2D, 0x5B, 0x4E, 0xD7, 0xFC, 0x31, 0x1C, 0xB0, 0x98, 0xEE, 0x6D, 0x6E,
    0xE0, 0x0E, 0x87, 0xA8, 0x75, 0x61, 0x91, 0x5F, 0x09, 0xC4, 0x5D, 0x2D, 0x00, 0x91, 0x99, 0x99,
    0x86, 0x5C, 0x93, 0x9E, 0x7D, 0x2B, 0xD0, 0xBE, 0x03, 0x7C, 0x53, 0xFF, 0x00, 0x84, 0x5E, 0xF7,
    0xFE, 0x11, 0x7D, 0x7E, 0x63, 0xFD, 0x92, 0xCF, 0xFE, 0x8F, 0x3B, 0x1F, 0xF8, 0xF6, 0x2C, 0x7A,
    0x1F, 0xF6, 0x0F, 0xE8, 0x79, 0xE8, 0x4E, 0x3D, 0x1A, 0xF0, 0x6F, 0xDE, 0x3C, 0xCC, 0x05, 0x75,
    0x07, 0xC8, 0xF6, 0x7F, 0x99, 0xEE, 0xBE, 0x05, 0xF0, 0xA8, 0xD1, 0xA6, 0x9B, 0xC5, 0x17, 0x17,
    0xB7, 0xC9, 0x27, 0xEF, 0x21, 0x68, 0x12, 0xE1, 0x95, 0x52, 0x00, 0xD9, 0x40, 0x17, 0x91, 0xC7,
    0xCD, 0xC7, 0x1F, 0x7B, 0xDA, 0xBC, 0xE7, 0xE3, 0x02, 0x69, 0x7E, 0x21, 0xD6, 0xAC, 0x96, 0x59,
    0xB5, 0x1B, 0xF3, 0xB9, 0x71, 0x6E, 0x81, 0x51, 0x1C, 0x03, 0x9C, 0x10, 0x8A, 0x33, 0xC9, 0x3E,
    0xA6, 0xBD, 0xC1, 0xFC, 0x51, 0x61, 0x65, 0xA3, 0x33, 0x88, 0x4D, 0xCA, 0x6D, 0x25, 0x5A, 0x15,
    0xDF, 0xB8, 0x1F, 0x61, 0xCD, 0x78, 0x3F, 0xC4, 0xAF, 0x89, 0xF1, 0xC2, 0xE6, 0x2D, 0x33, 0x4E,
    0xB8, 0x86, 0xE1, 0xB2, 0xBE, 0x6C, 0xD6, 0xED, 0x10, 0x51, 0xDF, 0x1B, 0x80, 0xCD, 0x71, 0x54,
    0x49, 0x45, 0x24, 0x7B, 0x57, 0xA7, 0x66, 0xE6, 0x8D, 0x1F, 0xDA, 0x1B, 0x5E, 0xB5, 0x55, 0xD1,
    0xB4, 0x0D, 0x39, 0x22, 0x89, 0x21, 0x81, 0x4F, 0x93, 0x18, 0x00, 0x44, 0xA0, 0x60, 0x2E, 0x07,
    0x4E, 0xFF, 0x00, 0x95, 0x70, 0x5A, 0x4F, 0x8C, 0x57, 0xFE, 0x12, 0x0B, 0x6D, 0x0E, 0x32, 0xAF,
    0x04, 0x71, 0x2A, 0x3B, 0x83, 0xD2, 0x43, 0xD8, 0x7E, 0x18, 0xAF, 0x35, 0xF1, 0x0F, 0x8A, 0x2E,
    0x6E, 0xEE, 0xA5, 0x68, 0xE6, 0x7B, 0x8B, 0xC9, 0x3E, 0xFC, 0xA4, 0xE7, 0x65, 0x64, 0x58, 0x4D,
    0x24, 0x24, 0xB2, 0xB1, 0xDC, 0x79, 0x24, 0x9E, 0x49, 0xF5, 0xAB, 0xA3, 0x16, 0xDB, 0x94, 0xBA,
    0x9E, 0x2E, 0x32, 0xBA, 0x95, 0xA3, 0x13, 0xFF, 0xD9 
};

ui_object * ui_config_create(uint8 *name, uint8 * text, uint16 width, uint16 height, void (* click)(ui_object *, void *)) {
	ui_icon_tool * obj = (ui_icon_tool *)ui_create_text(sizeof(ui_icon_tool), UI_TYPE_GRIDITEM | UI_ALIGN_GRID, (char *)text) ;
	((ui_object *)obj)->rect.w = width;
	((ui_object *)obj)->rect.h = height;
	strcpy((char *)((ui_object *)obj)->name, (const char *)name);
	((ui_object *)obj)->render = ui_icon_tool_render;
	((ui_object *)obj)->forecolor = UI_COLOR_LIME;
	((ui_object *)obj)->backcolor = UI_COLOR_QUEEN_BLUE;
	//((ui_object *)obj)->target = target;
	((ui_object *)obj)->handler = click;
	((ui_toggle *)obj)->state = 0;		//toggle off, enabled
	//strcpy((char *)obj->text, (const char *)text);
	if(width <= 40 || height <= 40) {
		obj->bitmap[0].bitmap = (uint8 *)image_png_setting24;
		obj->bitmap[0].bmpsize = sizeof(image_png_setting24);
		obj->bitmap[1].bitmap = (uint8 *)image_png_nfc24;
		obj->bitmap[1].bmpsize = sizeof(image_png_nfc24);
	} else {
		obj->bitmap[0].bitmap = (uint8 *)img_config_icon;
		obj->bitmap[0].bmpsize = sizeof(img_config_icon);
		obj->bitmap[1].bitmap = (uint8 *)img_png_nfc_icon48;
		obj->bitmap[1].bmpsize = sizeof(img_png_nfc_icon48);
	}
	return (ui_object *)obj;
}
